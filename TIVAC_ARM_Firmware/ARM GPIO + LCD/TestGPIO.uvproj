# Keil uVision project TestGPIO.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: TestGPIO
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_rvmdk.S main.c Gpio.h Gpio_Types.h STD_Types.h Port.h Port_Lcfg.c Bit_Math.h Gpio.c Kit_Connections.h Lcd.h Lcd.c Lcd_cfg.h Utils.h Utils.c
