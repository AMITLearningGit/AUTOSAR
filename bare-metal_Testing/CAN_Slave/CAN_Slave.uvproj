# Keil uVision project CAN_Slave.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: CAN_Slave
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ..\tivaware;..\tivaware\driverlib;..\tivaware\examples\boards\ek-tm4c123gxl;..\tivaware\driverlib\rvmdk;..\CAN_Slave
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c startup_rvmdk.S rgb.c CAN.c CAN.h CANInit.h CANInit_Config.h
    ../tivaware/utils/: uartstdio.c
  group Libs
    ../tivaware/driverlib/rvmdk/: driverlib.lib
